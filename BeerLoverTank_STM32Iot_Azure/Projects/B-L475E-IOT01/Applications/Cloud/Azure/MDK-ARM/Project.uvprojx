# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,EINVAL=-1,ENOMEM=EINVAL,MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>,ENABLE_IOT_ERROR,ENABLE_IOT_INFO,ENABLE_IOT_WARNING,SENSOR,USE_MBED_TLS,USE_WIFI,AZURE,DONT_USE_UPLOADTOBLOB,STRINGS_C_SPRINTF_BUFFER_SIZE=512
  c misc: --diag_suppress 177 --diag_suppress 188 --gnu
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/lsm303agr;../../../../../../Drivers/BSP/Components/M24SR;../../../WiFi/Inc;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/pal/generic;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/ST/lib_NDEF/inc;../Inc;../../../../../Common/Shared/Inc;../../../../../../Drivers/BSP/Components/vl53l0x;../../../../../Common/Azure/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Application/WiFi
    ../Src/: es_wifi_io.c wifi.c
  group Middlewares/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_message.c mqtt_codec.c mqtt_client.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_comp.c stm32l4xx_hal_opamp.c stm32l4xx_ll_lpuart.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_pcd.c stm32l4xx_hal_dma.c stm32l4xx_ll_utils.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_ll_rtc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_ll_tim.c stm32l4xx_hal_tsc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_sai.c stm32l4xx_ll_spi.c stm32l4xx_hal_adc.c stm32l4xx_hal_lcd.c stm32l4xx_ll_lptim.c stm32l4xx_ll_fmc.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_rng.c stm32l4xx_ll_rcc.c stm32l4xx_hal_spi.c stm32l4xx_hal_irda.c stm32l4xx_hal_sram.c stm32l4xx_ll_comp.c stm32l4xx_ll_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rng.c stm32l4xx_ll_dac.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_nor.c stm32l4xx_hal_cortex.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_usart.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_ll_crs.c stm32l4xx_ll_opamp.c stm32l4xx_hal_cryp.c stm32l4xx_ll_dma.c stm32l4xx_ll_adc.c stm32l4xx_ll_usb.c stm32l4xx_hal_flash.c stm32l4xx_hal_lptim.c stm32l4xx_ll_exti.c stm32l4xx_ll_usart.c stm32l4xx_hal_tim.c stm32l4xx_hal_crc.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_firewall.c stm32l4xx_ll_swpmi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_nand.c stm32l4xx_hal_pwr_ex.c stm32l4xx_ll_i2c.c stm32l4xx_ll_pwr.c stm32l4xx_ll_crc.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_smbus.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_sd.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: x509_create.c ccm.c pk_wrap.c pkwrite.c ecdh.c md.c x509.c havege.c ssl_cli.c pk.c version.c timing.c x509_crt.c cmac.c rsa.c camellia.c ecjpake.c xtea.c cipher_wrap.c oid.c ecp_curves.c ssl_srv.c ctr_drbg.c base64.c ripemd160.c sha1.c asn1parse.c x509write_crt.c ssl_ciphersuites.c md4.c ssl_cookie.c des.c dhm.c threading.c ecp.c md_wrap.c sha256.c arc4.c x509_csr.c blowfish.c entropy.c ssl_ticket.c bignum.c x509write_csr.c cipher.c pkcs12.c aes.c aesni.c platform.c ssl_tls.c hmac_drbg.c error.c gcm.c version_features.c memory_buffer_alloc.c padlock.c md2.c md5.c ssl_cache.c x509_crl.c asn1write.c ecdsa.c pkcs11.c sha512.c certs.c debug.c pkparse.c entropy_poll.c pkcs5.c pem.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_api_core.c vl53l0x_platform_log.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01_tsensor.c stm32l475e_iot01_psensor.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_accelero.c stm32l475e_iot01.c stm32l475e_iot01_gyro.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Middlewares/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
  group Application/User
    ../Src/: vl53l0x_proximity.c flash_l4.c vl53l0x_platform.c stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Middlewares/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: optionhandler.c map.c httpapiex.c consolelogger.c crt_abstractions.c singlylinkedlist.c gballoc.c sha224.c sastoken.c sha1.c hmac.c strings.c constmap.c sha384-512.c vector.c xio.c buffer.c gb_time.c usha.c connection_string_parser.c http_proxy_io.c urlencode.c string_tokenizer.c gb_rand.c wsio.c doublylinkedlist.c gb_stdio.c httpapiexsas.c utf8_checker.c uws_frame_encoder.c base64.c hmacsha256.c xlogging.c uws_client.c httpheaders.c constbuffer.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Middlewares/azure-iot-sdk-c/iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: version.c iothubtransport.c iothub_client.c iothub_client_retry_control.c iothub_client_authorization.c iothub_client_diagnostic.c iothub_client_ll.c iothubtransport_mqtt_common.c iothub_client_ll_uploadtoblob.c blob.c iothub_message.c iothubtransportmqtt_websockets.c iothubtransportmqtt.c
  group Application/Azure
    ../../../../../Common/Azure/Src/: azure_sha1.c az_tlsio_mbedtls.c az_platform_STM32Cube.c az_socketio_mbed.c az_tcpsocketconnection_c_STM32Cube.c azure_version.c az_threadapi_STM32Cube.c AzureXcubeSample.c az_tickcounter_STM32Cube.c azure_base64.c
  group Application/Common
    ../../../../../Common/Shared/Src/: rfu.c http_util.c cloud.c STM32CubeRTCInterface.c timedate.c iot_flash_config.c net_tcp_wifi.c net_tls_mbedtls.c sensors_data.c timingSystem.c net.c mbedtls_net.c wifi_net.c entropy_hardware_poll.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Middlewares/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: agenttypesystem.c iotdevice.c jsonencoder.c jsondecoder.c schemalib.c dataserializer.c codefirst.c datapublisher.c schema.c commanddecoder.c schemaserializer.c multitree.c methodreturn.c datamarshaller.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
software components: CMSIS:CORE 4.3.0
